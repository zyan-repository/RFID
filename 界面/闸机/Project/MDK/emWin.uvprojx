# Keil uVision project emWin.uvprojx, settings and files
target emWin (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: emWin +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c misc: --locale=english
  c include: ..\..\App;..\..\App\Demo\Include;..\..\Board\Include;..\..\Chip\CMSIS;..\..\Chip\STM32F4xx_StdPeriph_Driver\inc;..\..\App\fonts;..\..\App\emWin\Config;..\..\App\emWin\emWinTask;..\..\App\emWin\GUI_X;..\..\App\emWin\Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group App
    ../../App/: main.c stm32f4xx_it.c Queue.c
    ../../App/Demo/Source/: Test_emWin.c
  group Board
    ../../Board/Source/: BSP_DebugUART.c BSP_Delay.c BSP_MyIIC.c BSP_GSL268x.c BSP_Timer.c BSP_TouchPad.c BSP_ParallelBus.c BSP_RA8875.c BSP_RA8875_Port.c BSP_TFTLCD.c BSP_SRAM.c BSP_UART.c BSP_ST16C554.c
  group CMSIS
    ../../Chip/CMSIS/startup/: startup_stm32f40_41xxx.s
    ../../Chip/CMSIS/: system_stm32f4xx.c
  group StdPeriph_Driver
    ../../Chip/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group fonts
    ../../App/fonts/: asc12.c asc16.c hz12.c hz16.c hz24.c hz32.c ra8875_asc_width.c FontSong.c
  group GUI/Driver
    ../../App/emWin/DisplayDriver/: GUIDRV_Template.c
  group GUI_X
    ../../App/emWin/GUI_X/: GUI_X.c
  group GUI/Config
    ../../App/emWin/Config/: GUIConf.c GUIConf.h LCDConf.c LCDConf.h
  group GUI/DEMO
    ../../App/emWin/emWinTask/: MainTask.c MainTask.h
  group GUI/Lib
    ../../App/emWin/GUILib/: STemWin528_CM4_Keil_ot.lib
  group Doc
    ../../Document/: Readme.txt
